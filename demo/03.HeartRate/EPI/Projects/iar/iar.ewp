# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../; ../../Apps\; ../../Drivers\MED03212P\; ../../../../../lib\libcox; ../../../../../lib\libcookie; ../../../../../lib\startup\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: main.c
  group Cookie
    ../../../../../lib/libcookie/: cookie.h cookie_cfg.h
  group CoX/inc
    ../../../../../lib/libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_adc.h xhw_config.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group CoX/src
    ../../../../../lib/libcox/: xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group Drivers
    ../../Drivers/OV9650/: ov9650.h
  group Drivers/MED03212P
    ../../Drivers/MED03212P/: med03212.c med03212.h
  group src
    ../../Apps/: delay.c
  group Startup
    ../../../../../lib/startup/src/: startup_ewarm.s
